PRINC = "2"
FILESEXTRAPATHS := "${THISDIR}/files"

SPLASH_IMAGES += " file://psplash-jlime-img.png"
