PACKAGECONFIG = "consolekit"
PRINC = "1"
